# Keil uVision project STM32L431_SFCS.uvprojx, settings and files
target SFCS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L431_SFCS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\Drivers\SYSTEM;..\..\User;..\..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l431xx.s
  group User
    ../../User/: main.c stm32l4xx_it.c node.c
    ../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Driver/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Driver/STM32L4xx_HAL_Driver
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_adc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_rcc.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_ll_pwr.c
  group Driver/BSP
    ../../Drivers/BSP/CAN/: can.c
    ../../Drivers/BSP/QUERY/: query.c
    ../../Drivers/BSP/RS485/: rs485.c
    ../../Drivers/BSP/GPIO/: gpio.c
    ../../Drivers/BSP/RCMDI/: rcmdi.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ATIMER/: atim.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/LOCKPWM/: lockpwm.c
    ../../Drivers/BSP/QUERYTIMER/: queryabcap.c
